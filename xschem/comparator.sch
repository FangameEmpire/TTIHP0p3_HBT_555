v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/IHP-Open-PDK/ihp-sg13g2/libs.tech/xschem/sg13g2_pr/npn13G2.sym} 140 40 0 0 {name=Q1
model=npn13G2
spiceprefix=X
Nx=1
}
C {/foss/designs/IHP-Open-PDK/ihp-sg13g2/libs.tech/xschem/sg13g2_pr/npn13G2.sym} 60 40 0 1 {name=Q2
model=npn13G2
spiceprefix=X
Nx=1
}
